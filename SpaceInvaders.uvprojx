# Keil uVision project SpaceInvaders.uvprojx, settings and files
target SpaceInvaders (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SpaceInvaders
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s random.s SystemInfo.h SystemInfo.c DAC.c ADC.c Timer0.c Timer1.c Sound.c LCD.s Print.s SpaceInvaders.c ST7735.c PLL.c Draw.h Draw.c Field.h Field.c PokemonType.h PokemonType.c Pokemon.h Pokemon.c Battle.h Player.h Player.c Battle.c Shop.h Shop.c ImagesOther.h
software components: CMSIS:CORE 5.1.2
